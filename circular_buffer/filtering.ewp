# IAR project filtering.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: RX600 Generic RX600
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCRX.IccLang: 0
  ILINK.IlinkOutputFile: filtering.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (RX)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  group (top)
    ./: moving_average_with_circular_buffer_V2.0.c moving_average_with_circular_buffer_V2.0.h
